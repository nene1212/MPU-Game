# Keil uVision project oled.uvprojx, settings and files
target OLED (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: oled +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARELIB;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARELIB\MPU6050;..\HARDWARELIB\IIC;..\HARDWARELIB\MPU6050\eMPL;..\HARDWARELIB\GAME_BALL;..\HARDWARELIB\TIMER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../STM32F10x_FWLib/src/: stm32f10x_tim.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group HARDWARELIB
    ../HARDWARELIB/: oled.c
    ../HARDWARELIB/MPU6050/: mpu6050.c
    ../HARDWARELIB/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARELIB/IIC/: myiic.c
    ../HARDWARELIB/GAME_BALL/: GAME_BALL .C
    ../HARDWARELIB/TIMER/: timer.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_i2c.c
